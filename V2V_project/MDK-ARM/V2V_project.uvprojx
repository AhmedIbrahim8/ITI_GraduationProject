# Keil uVision project V2V_project.uvprojx, settings and files
target V2V_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: V2V_project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c App.c DCM_PBconfig.c DCM_Program.c Delay.c GPT_PBconfig.c GPT_Program.c HIR_Program.c LINE_FOLLOWER_PROGRAM.c main_speed.c MEXTI_Program.c MGPIO_Program.c MNIVC_Program.c MRCC_Program.c MSYSTICK_Program.c OPTO_COUPLER.c Servo_Program.c system_stm32f4xx.c Ultrasonic.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Application/User/Core\Inc
    ../Core/Inc/: App.h BIT_MATH.h DCM_Config.h DCM_Interface.h DCM_Private.h Delay.h GPT_Config.h GPT_Interface.h GPT_Private.h HIR_Config.h HIR_Interface.h HIR_Private.h LINE_FOLLOWER_CONFIG.h LINE_FOLLOWER_INTERFACE.h main.h MEXTI_Config.h MEXTI_Interface.h MEXTI_Private.h MGPIO_Config.h MGPIO_Interface.h MGPIO_Private.h MNVIC_Config.h MNVIC_Interface.h MNVIC_Private.h MRCC_Config.h MRCC_Interface.h MRCC_Private.h MSYSTICK_Config.h MSYSTICK_Interface.h MSYSTICK_Private.h OPTO_COUPLER_INTERFACE.h SERVO_config.h SERVO_Interface.h SERVO_private.h STD_Types.h stm32f4xx_hal_conf.h stm32f4xx_it.h ULTRASONIC_Config.h ULTRASONIC_Interface.h
software components: CMSIS:CORE 4.3.0
