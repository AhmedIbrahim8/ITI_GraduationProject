# Keil uVision project Application_arm_keil.uvprojx, settings and files
target Application_arm_keil (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Application_arm_keil +hex
  AfterMake: fromelf.exe --bin --output=Application_arm_keil/Application.bin Application_arm_keil/Application_arm_keil.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include; ../Application
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/Application
    ../Application/: App.c App.h BIT_MATH.h DCM_Config.h DCM_Interface.h DCM_PBconfig.c DCM_Private.h DCM_Program.c Delay.c Delay.h GPT_Config.h GPT_Interface.h GPT_PBconfig.c GPT_Private.h GPT_Program.c LINE_FOLLOWER_CONFIG.h LINE_FOLLOWER_INTERFACE.h LINE_FOLLOWER_PROGRAM.c main_simple_autonomous_RC.c MEXTI_Config.h MEXTI_Interface.h MEXTI_Private.h MEXTI_Program.c MGPIO_Config.h MGPIO_Interface.h MGPIO_Private.h MGPIO_Program.c MNIVC_Program.c MNVIC_Config.h MNVIC_Interface.h MNVIC_Private.h MRCC_Config.h MRCC_Interface.h MRCC_Private.h MRCC_Program.c OPTO_COUPLER.c OPTO_COUPLER_INTERFACE.h SERVO_config.h SERVO_Interface.h SERVO_private.h Servo_Program.c STD_Types.h Ultrasonic.c ULTRASONIC_Config.h ULTRASONIC_Interface.h
software components: CMSIS:CORE 4.3.0
